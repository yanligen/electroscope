# Keil uVision project es.uvprojx, settings and files
target ElectroScope (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M058ZDN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: es +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Library\CMSIS\Include;.\Library\Device\Nuvoton\M051Series\Include;.\Library\StdDriver\inc;.\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ./Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group User
    ./: main.c interrupt.c
  group Library
    ./Library/StdDriver/src/: acmp.c adc.c clk.c ebi.c FMC.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c mcp41100.c sample.c
